<?xml version="1.0" encoding="UTF-8" standalone="no" ?>
<ProjectOpt xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:noNamespaceSchemaLocation="project_opt.xsd">

  <SchemaVersion>1.0</SchemaVersion>

  <Header>### uVision Project, (C) Keil Software</Header>

  <Extensions>
    <cExt>*.c</cExt>
    <aExt>*.s*; *.src; *.a*</aExt>
    <oExt>*.obj</oExt>
    <lExt>*.lib</lExt>
    <tExt>*.txt; *.h; *.inc</tExt>
    <pExt>*.plm</pExt>
    <CppX>*.cpp</CppX>
  </Extensions>

  <DaveTm>
    <dwLowDateTime>0</dwLowDateTime>
    <dwHighDateTime>0</dwHighDateTime>
  </DaveTm>

  <Target>
    <TargetName>LPC1768_SIM</TargetName>
    <ToolsetNumber>0x4</ToolsetNumber>
    <ToolsetName>ARM-ADS</ToolsetName>
    <TargetOption>
      <CLKADS>12000000</CLKADS>
      <OPTTT>
        <gFlags>1</gFlags>
        <BeepAtEnd>1</BeepAtEnd>
        <RunSim>1</RunSim>
        <RunTarget>0</RunTarget>
      </OPTTT>
      <OPTHX>
        <HexSelection>1</HexSelection>
        <FlashByte>65535</FlashByte>
        <HexRangeLowAddress>0</HexRangeLowAddress>
        <HexRangeHighAddress>0</HexRangeHighAddress>
        <HexOffset>0</HexOffset>
      </OPTHX>
      <OPTLEX>
        <PageWidth>79</PageWidth>
        <PageLength>66</PageLength>
        <TabStop>8</TabStop>
        <ListingPath>.\</ListingPath>
      </OPTLEX>
      <ListingPage>
        <CreateCListing>1</CreateCListing>
        <CreateAListing>1</CreateAListing>
        <CreateLListing>1</CreateLListing>
        <CreateIListing>0</CreateIListing>
        <AsmCond>1</AsmCond>
        <AsmSymb>1</AsmSymb>
        <AsmXref>0</AsmXref>
        <CCond>1</CCond>
        <CCode>0</CCode>
        <CListInc>0</CListInc>
        <CSymb>0</CSymb>
        <LinkerCodeListing>0</LinkerCodeListing>
      </ListingPage>
      <OPTXL>
        <LMap>1</LMap>
        <LComments>1</LComments>
        <LGenerateSymbols>1</LGenerateSymbols>
        <LLibSym>1</LLibSym>
        <LLines>1</LLines>
        <LLocSym>1</LLocSym>
        <LPubSym>1</LPubSym>
        <LXref>0</LXref>
        <LExpSel>0</LExpSel>
      </OPTXL>
      <OPTFL>
        <tvExp>1</tvExp>
        <tvExpOptDlg>0</tvExpOptDlg>
        <IsCurrentTarget>1</IsCurrentTarget>
      </OPTFL>
      <CpuCode>8</CpuCode>
      <Books>
        <Book>
          <Number>0</Number>
          <Title>Data Sheet</Title>
          <Path>DATASHTS\PHILIPS\LPC176x_DS.pdf</Path>
        </Book>
        <Book>
          <Number>1</Number>
          <Title>User Manual</Title>
          <Path>DATASHTS\PHILIPS\LPC17xx_UM.pdf</Path>
        </Book>
        <Book>
          <Number>2</Number>
          <Title>Errata Sheet</Title>
          <Path>DATASHTS\PHILIPS\LPC1768_ES.pdf</Path>
        </Book>
      </Books>
      <DllOpt>
        <SimDllName>SARMCM3.DLL</SimDllName>
        <SimDllArguments>-MPU</SimDllArguments>
        <SimDlgDllName>DARMP1.DLL</SimDlgDllName>
        <SimDlgDllArguments>-pLPC1768</SimDlgDllArguments>
        <TargetDllName>SARMCM3.DLL</TargetDllName>
        <TargetDllArguments>-MPU</TargetDllArguments>
        <TargetDlgDllName>TARMP1.DLL</TargetDlgDllName>
        <TargetDlgDllArguments>-pLPC1768</TargetDlgDllArguments>
      </DllOpt>
      <DebugOpt>
        <uSim>1</uSim>
        <uTrg>0</uTrg>
        <sLdApp>1</sLdApp>
        <sGomain>1</sGomain>
        <sRbreak>1</sRbreak>
        <sRwatch>1</sRwatch>
        <sRmem>1</sRmem>
        <sRfunc>1</sRfunc>
        <sRbox>1</sRbox>
        <tLdApp>1</tLdApp>
        <tGomain>0</tGomain>
        <tRbreak>1</tRbreak>
        <tRwatch>1</tRwatch>
        <tRmem>1</tRmem>
        <tRfunc>0</tRfunc>
        <tRbox>1</tRbox>
        <sRunDeb>0</sRunDeb>
        <sLrtime>0</sLrtime>
        <nTsel>1</nTsel>
        <sDll></sDll>
        <sDllPa></sDllPa>
        <sDlgDll></sDlgDll>
        <sDlgPa></sDlgPa>
        <sIfile></sIfile>
        <tDll></tDll>
        <tDllPa></tDllPa>
        <tDlgDll></tDlgDll>
        <tDlgPa></tDlgPa>
        <tIfile></tIfile>
        <pMon></pMon>
      </DebugOpt>
      <TargetDriverDllRegistry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>DLGDARM</Key>
          <Name>(1010=-1,-1,-1,-1,0)(1007=-1,-1,-1,-1,0)(1008=-1,-1,-1,-1,0)(1009=-1,-1,-1,-1,0)(1012=-1,-1,-1,-1,0)(350=-1,-1,-1,-1,0)(250=-1,-1,-1,-1,0)(270=-1,-1,-1,-1,0)(313=-1,-1,-1,-1,0)(291=-1,-1,-1,-1,0)(302=-1,-1,-1,-1,0)(110=-1,-1,-1,-1,0)(113=-1,-1,-1,-1,0)(320=-1,-1,-1,-1,0)(210=-1,-1,-1,-1,0)(330=-1,-1,-1,-1,0)(332=-1,-1,-1,-1,0)(333=150,189,738,381,0)(334=594,405,1182,597,0)(335=-1,-1,-1,-1,0)(336=-1,-1,-1,-1,0)(345=-1,-1,-1,-1,0)(346=154,272,742,464,0)(381=739,251,1114,800,0)(382=-1,-1,-1,-1,0)(383=-1,-1,-1,-1,0)(384=-1,-1,-1,-1,0)(197=-1,-1,-1,-1,0)(198=-1,-1,-1,-1,0)(191=-1,-1,-1,-1,0)(192=-1,-1,-1,-1,0)(199=-1,-1,-1,-1,0)(180=-1,-1,-1,-1,0)(261=-1,-1,-1,-1,0)(262=-1,-1,-1,-1,0)(231=-1,-1,-1,-1,0)(232=-1,-1,-1,-1,0)(233=-1,-1,-1,-1,0)(121=-1,-1,-1,-1,0)(122=-1,-1,-1,-1,0)(123=-1,-1,-1,-1,0)(124=-1,-1,-1,-1,0)(170=-1,-1,-1,-1,0)(142=-1,-1,-1,-1,0)(150=-1,-1,-1,-1,0)(400=-1,-1,-1,-1,0)(370=-1,-1,-1,-1,0)(160=-1,-1,-1,-1,0)(280=-1,-1,-1,-1,0)(240=-1,-1,-1,-1,0)</Name>
        </SetRegEntry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>ARMDBGFLAGS</Key>
          <Name>-T0</Name>
        </SetRegEntry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>UL2CM3</Key>
          <Name>-O463 -S0 -C0 -FO7 -FD10000000 -FC800 -FN1 -FF0LPC_IAP_512 -FS00 -FL080000)</Name>
        </SetRegEntry>
      </TargetDriverDllRegistry>
      <MemoryWindow1>
        <Mm>
          <WinNumber>1</WinNumber>
          <SubType>8</SubType>
          <ItemText>buffer_tx</ItemText>
        </Mm>
      </MemoryWindow1>
      <DebugFlag>
        <trace>0</trace>
        <periodic>1</periodic>
        <aLwin>1</aLwin>
        <aCover>0</aCover>
        <aSer1>1</aSer1>
        <aSer2>0</aSer2>
        <aPa>0</aPa>
        <viewmode>1</viewmode>
        <vrSel>0</vrSel>
        <aSym>0</aSym>
        <aTbox>0</aTbox>
        <AscS1>0</AscS1>
        <AscS2>0</AscS2>
        <AscS3>0</AscS3>
        <aSer3>0</aSer3>
        <eProf>0</eProf>
        <aLa>1</aLa>
        <aPa1>0</aPa1>
        <AscS4>0</AscS4>
        <aSer4>0</aSer4>
        <StkLoc>0</StkLoc>
        <TrcWin>0</TrcWin>
        <newCpu>0</newCpu>
        <uProt>0</uProt>
      </DebugFlag>
      <LintExecutable></LintExecutable>
      <LintConfigFile></LintConfigFile>
      <LogicAnalyzers>
        <Wi>
          <IntNumber>0</IntNumber>
          <FirstString>(FIO1PIN &amp; 0x100000) &gt;&gt; 20</FirstString>
          <SecondString>FF0000000000000000000000000000000000F03F0100000000000000000000000000000046494F3150494E00000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000010000000000000000000000000000000000000000000000000000000000000000000000A8010000</SecondString>
        </Wi>
        <Wi>
          <IntNumber>1</IntNumber>
          <FirstString>(FIO1PIN &amp; 0x200000) &gt;&gt; 21</FirstString>
          <SecondString>00800000000000000000000000000000E0FFEF400100000000000000000000000000000046494F3150494E00000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000010000000000000000000000000000000000000000000000000000000000000000000000A8010000</SecondString>
        </Wi>
        <Wi>
          <IntNumber>2</IntNumber>
          <FirstString>(FIO1PIN &amp; 0x400000) &gt;&gt; 22</FirstString>
          <SecondString>00008000000000000000000000000000E0FFEF400100000000000000000000000000000046494F3150494E00000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000010000000000000000000000000000000000000000000000000000000000000000000000A8010000</SecondString>
        </Wi>
        <Wi>
          <IntNumber>3</IntNumber>
          <FirstString>(FIO1PIN &amp; 0x800000) &gt;&gt; 23</FirstString>
          <SecondString>00000000000000000000000000000000E0FFEF400100000000000000000000000000000046494F3150494E00000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000010000000000000000000000000000000000000000000000000000000000000000000000A8010000</SecondString>
        </Wi>
        <Wi>
          <IntNumber>4</IntNumber>
          <FirstString>(FIO1PIN &amp; 0x1000000) &gt;&gt; 24</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF400100000000000000000000000000000046494F3150494E00000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000010000000000000000000000000000000000000000000000000000000000000000000000A8010000</SecondString>
        </Wi>
        <Wi>
          <IntNumber>5</IntNumber>
          <FirstString>(FIO1PIN &amp; 0x2000000) &gt;&gt; 25</FirstString>
          <SecondString>00800000000000000000000000000000E0FFEF400100000000000000000000000000000046494F3150494E00000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000010000000000000000000000000000000000000000000000000000000000000000000000A8010000</SecondString>
        </Wi>
        <Wi>
          <IntNumber>6</IntNumber>
          <FirstString>(FIO1PIN &amp; 0x4000000) &gt;&gt; 26</FirstString>
          <SecondString>00008000000000000000000000000000E0FFEF400100000000000000000000000000000046494F3150494E00000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000010000000000000000000000000000000000000000000000000000000000000000000000A8010000</SecondString>
        </Wi>
        <Wi>
          <IntNumber>7</IntNumber>
          <FirstString>(FIO1PIN &amp; 0x8000000) &gt;&gt; 27</FirstString>
          <SecondString>00000000000000000000000000000000E0FFEF400100000000000000000000000000000046494F3150494E00000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000010000000000000000000000000000000000000000000000000000000000000000000000A8010000</SecondString>
        </Wi>
        <Wi>
          <IntNumber>8</IntNumber>
          <FirstString>(FIO1PIN &amp; 0x10000000) &gt;&gt; 28</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF400100000000000000000000000000000046494F3150494E00000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000010000000000000000000000000000000000000000000000000000000000000000000000A8010000</SecondString>
        </Wi>
        <Wi>
          <IntNumber>9</IntNumber>
          <FirstString>(FIO1PIN &amp; 0x20000000) &gt;&gt; 29</FirstString>
          <SecondString>00800000000000000000000000000000E0FFEF400100000000000000000000000000000046494F3150494E00000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000010000000000000000000000000000000000000000000000000000000000000000000000A8010000</SecondString>
        </Wi>
        <Wi>
          <IntNumber>10</IntNumber>
          <FirstString>(FIO2PIN &amp; 0x800) &gt;&gt; 11</FirstString>
          <SecondString>00800000000000000000000000000000E0FFEF400100000000000000000000000000000046494F3250494E00000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000010000000000000000000000000000000000000000000000000000000000000000000000F8010000</SecondString>
        </Wi>
        <Wi>
          <IntNumber>11</IntNumber>
          <FirstString>(PORT2 &amp; 0x1000) &gt;&gt; 12</FirstString>
          <SecondString>00008000000000000000000000000000E0FFEF4001000000000000000000000000000000504F525432000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000010000000000000000000000000000000000000000000000000000000000000000000000F8010000</SecondString>
        </Wi>
        <Wi>
          <IntNumber>12</IntNumber>
          <FirstString>(PORT2 &amp; 0x2000) &gt;&gt; 13</FirstString>
          <SecondString>00000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F525432000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000010000000000000000000000000000000000000000000000000000000000000000000000F8010000</SecondString>
        </Wi>
      </LogicAnalyzers>
    </TargetOption>
  </Target>

  <Group>
    <GroupName>Startup</GroupName>
    <tvExp>1</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>1</FileNumber>
      <FileType>2</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>129</TopLine>
      <CurrentLine>129</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>.\startup_LPC17xx.s</PathWithFileName>
      <FilenameWithoutPath>startup_LPC17xx.s</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>2</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>110</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>59</TopLine>
      <CurrentLine>59</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>.\system_LPC17xx.c</PathWithFileName>
      <FilenameWithoutPath>system_LPC17xx.c</FilenameWithoutPath>
    </File>
  </Group>

  <Group>
    <GroupName>Sources</GroupName>
    <tvExp>1</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>3</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>41</TopLine>
      <CurrentLine>41</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>.\main.c</PathWithFileName>
      <FilenameWithoutPath>main.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>4</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>23</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>261</TopLine>
      <CurrentLine>263</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>.\funciones.c</PathWithFileName>
      <FilenameWithoutPath>funciones.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>5</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>17</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>1</TopLine>
      <CurrentLine>1</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>.\configuraciones.c</PathWithFileName>
      <FilenameWithoutPath>configuraciones.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>6</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>54</TopLine>
      <CurrentLine>57</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>.\Interrup.c</PathWithFileName>
      <FilenameWithoutPath>Interrup.c</FilenameWithoutPath>
    </File>
  </Group>

  <AlienFiles>
    <PathWithFilename>C:\Users\manuel\Desktop\proyecto final\definiciones.h</PathWithFilename>
    <TopLine>30</TopLine>
    <CurrentLine>30</CurrentLine>
    <Constant>0</Constant>
    <WindowPosition>
      <length>0</length>
      <flags>0</flags>
      <showCmd>0</showCmd>
      <MinPosition>
        <xPos>0</xPos>
        <yPos>0</yPos>
      </MinPosition>
      <MaxPosition>
        <xPos>0</xPos>
        <yPos>0</yPos>
      </MaxPosition>
      <NormalPosition>
        <Top>0</Top>
        <Left>0</Left>
        <Right>0</Right>
        <Bottom>0</Bottom>
      </NormalPosition>
    </WindowPosition>
  </AlienFiles>

  <MDIGroups>
    <Orientation>1</Orientation>
    <ActiveMDIGroup>0</ActiveMDIGroup>
    <MDIGroup>
      <Size>100</Size>
      <ActiveTab>2</ActiveTab>
      <Documents>
        <Doc>
          <Name>definiciones.h</Name>
          <ColumnNumber>112</ColumnNumber>
          <TopLine>30</TopLine>
          <CurrentLine>30</CurrentLine>
        </Doc>
        <Doc>
          <Name>.\main.c</Name>
          <ColumnNumber>0</ColumnNumber>
          <TopLine>41</TopLine>
          <CurrentLine>41</CurrentLine>
        </Doc>
        <Doc>
          <Name>.\funciones.c</Name>
          <ColumnNumber>23</ColumnNumber>
          <TopLine>261</TopLine>
          <CurrentLine>263</CurrentLine>
        </Doc>
        <Doc>
          <Name>.\configuraciones.c</Name>
          <ColumnNumber>17</ColumnNumber>
          <TopLine>1</TopLine>
          <CurrentLine>1</CurrentLine>
        </Doc>
        <Doc>
          <Name>.\Interrup.c</Name>
          <ColumnNumber>0</ColumnNumber>
          <TopLine>54</TopLine>
          <CurrentLine>57</CurrentLine>
        </Doc>
        <Doc>
          <Name>.\startup_LPC17xx.s</Name>
          <ColumnNumber>0</ColumnNumber>
          <TopLine>129</TopLine>
          <CurrentLine>129</CurrentLine>
        </Doc>
        <Doc>
          <Name>.\system_LPC17xx.c</Name>
          <ColumnNumber>110</ColumnNumber>
          <TopLine>59</TopLine>
          <CurrentLine>59</CurrentLine>
        </Doc>
      </Documents>
    </MDIGroup>
  </MDIGroups>

</ProjectOpt>
